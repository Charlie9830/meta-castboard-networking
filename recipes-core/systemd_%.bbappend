PACKAGECONFIG_append = " network resolved"
